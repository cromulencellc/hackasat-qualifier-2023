options:
  parameters:
    author: cromulence
    generate_options: no_gui
    id: solver
    output_language: python
    run_options: run
    title: qam solver
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bitrate/bps
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../out/symbols
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '4'
    l: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,
                  symbol_map = [],
                  constellation_points = [],
                  tolerance = 1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='QAM Slicer',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tolSq = tolerance ** 2
              self.map = {constellation_points[i]: symbol_map[i] for i in range(len(constellation_points))}
              self.const = constellation_points
              self.log = gr.logger(self.alias())
              self.log.debug("QAM Slicer initialized")

          def work(self, input_items, output_items):
              i=0
              for s in input_items[0]:
                  for sym in self.const:
                      c = s - sym
                      rSq = c.real ** 2 + c.imag ** 2
                      if rSq < self.tolSq:
                          output_items[0][i] = self.map[sym]
                          break 
                  i += 1
              return len(output_items[0])
    constellation_points: ' [(-3-3j), (-3-1j), (-3+1j), (-3+3j), (-1-3j), (-1-1j), (-1+1j), (-1+3j), (1-3j), (1-1j), (1+1j), (1+3j), (3-3j), (3-1j), (3+1j), (3+3j)]'
    symbol_map: '[0x0, 0x1, 0x2, 0x3, 0x4, 0x5, 0x6, 0x7, 0x8, 0x9, 0xA, 0xB, 0xC, 0xD, 0xE, 0xF]'
    tolerance: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    marker1: '0'
    marker2: '7'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
