options:
  parameters:
    author: Cromulence
    generate_options: no_gui
    id: solver
    output_language: python
    run_options: run
    title: satsig solver
  states: {}

blocks:
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    cons: constellation
    delta: '40'
    ffactor: '.99'
    modulus: '4'
    step_size: '100e-6'
    type: lms
  states: {state: disabled}
- name: audio_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: modulated_preamble
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x1a, 0xcf, 0xfc, 0x1d]'
  states: {state: disabled}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constellation, True, sps, True, 0.35, False, False)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-1e3'
    sample_rate: samp_rate
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 300*sps
    type: complex
  states: {state: bypassed}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: '1024'
    type: byte
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (17, 83)
    type: byte
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (40, 43)
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../out/signal.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: ../data/delfi.wav
    repeat: 'True'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00011010110011111111110000011101'
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 6.28/100.0
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_1
  id: digital_linear_equalizer
  parameters:
    alg: alg
    num_taps: '15'
    sps: '2'
    training_sequence: modulated_preamble
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps*2
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation
    damping: '1.2'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Print Flag',   # will show up in GRC
                  in_sig=[np.ubyte],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def general_work(self, input_items, output_items):
              print("Test")
              #print(len(input_items[0]))
              return
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: bitrate*sps
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate/100/2)
    fbw: '0.35'
    interp: int(bitrate*sps/100)
    type: ccc
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_head_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_head_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_demux_0, '1', blocks_stream_demux_0_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_head_1, '0']
- [blocks_stream_demux_0_0, '0', epy_block_0, '0']
- [blocks_stream_demux_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', audio_sink_0, '1']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_1, '0', qtgui_sink_x_0_0, '0']
- [digital_map_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
