options:
  parameters:
    author: cromulence
    generate_options: no_gui
    id: satsig
    output_language: python
    run_options: run
    title: satsig
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: interp_des
  id: variable
  parameters:
    value: samp_rate/sps/bitrate
  states: {}
- name: pkt_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(64e3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("flag")
    file: tx_stream
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 1e3
    sample_rate: samp_rate
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '528'
    type: byte
  states: {state: bypassed}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: signal.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: audio_rate
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '.01'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e3
    decim: '1'
    gain: '0.3'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1.5e2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2
    decim: '1'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '1200'
    srate: bitrate*8
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"flag"'
    type: float
    ylabel: Bits
    ymax: '1.2'
    ymin: '-.2'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(bitrate*sps/100)
    interp: int(samp_rate/100)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/100)
    interp: int(audio_rate/100)
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_head_0, '0', digital_constellation_modulator_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', channels_channel_model_0, '0']
- [low_pass_filter_0_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0_0_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
